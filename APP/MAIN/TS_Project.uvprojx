# Keil uVision project TS_Project.uvprojx, settings and files
target APU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TOY +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,EASY_OS,DEBUG_INFO_ENABLE
  c include: ..\main;..\applications;..\..\OS\OS_Driver;..\..\OS\OS_Task;..\..\RTE;..\..\TYPES;..\..\RTE;..\..\LIB;..\..\BSW;..\..\Cfg\BSW_Cfg;..\..\MCAL;..\..\ext-driver;..\..\Cfg\MCAL_Cfg;..\..\APP;..\..\DRIVER\Chip_Driver\STM32F1\Library\Driver\CMSIS;..\..\DRIVER\Chip_Driver\STM32F1\Library\Standard_Library\inc;..\..\DRIVER\Chip_Driver\STM32F1\User_Interface;..\..\OS\FreeRTOS\Source\include;..\..\OS\FreeRTOS\Source\portable\MemMang;..\..\OS\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\DRIVER\Chip_Driver\STM32F1\sys_bitBand
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./: main.c
    ../: OS_TASK.c FreeRTOS_TASK.c
    ../applications/: APP_test.c
  group OS
    ../../OS/OS_Driver/: Os_BaseTimer.c Os_EvtHdl.c Os_TimerHdl.c
    ../../OS/OS_Task/: Os_TaskHdl_Lv0.c Os_TaskHdl_Lv1.c Os_TaskHdl_Lv2.c
    ../../OS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../OS/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../OS/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group RTE
    ../../RTE/: RTE.c
  group Standard_Library
    ../../DRIVER/Chip_Driver/STM32F1/Library/Standard_Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Chip_Driver
    ../../DRIVER/Chip_Driver/STM32F1/Library/Driver/CMSIS/: core_cm3.c system_stm32f10x.c
    ../../DRIVER/Chip_Driver/STM32F1/Library/Driver/Startup/: startup_stm32f10x_hd.s
    ../../DRIVER/Chip_Driver/STM32F1/User_Interface/: stm32f10x_it.c
    ../../DRIVER/Chip_Driver/STM32F1/sys_bitBand/: sys.c
  group MCAL
    ../../MCAL/: MCAL_GPIO.c MCAL_Uart.c
  group LIB
    ../../LIB/: Lib_Log_Util.c
  group ext-driver
    ../../ext-driver/: Ext_MPU6050.c
